# IAR project AT_Master.ewp, settings and files
configuration I_NUCLEO_LRWAN1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_BAND_868; USE_STM32L0XX_NUCLEO; USE_I_NUCLEO_LRWAN1
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/MDM32L07X01; ../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AT_Master.bin
  ILINK.IlinkOutputFile: I_NUCLEO_LRWAN1.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MDM32L07X01 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_BAND_868; USE_STM32L0XX_NUCLEO; USE_MDM32L07X01
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/MDM32L07X01; ../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities
  ILINK.IlinkOutputFile: MDM32L07X01.out
configuration LRWAN_NS1 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_BAND_868; USE_STM32L0XX_NUCLEO; USE_LRWAN_NS1; CMD_DEBUG
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/LRWAN_NS1; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities
  ILINK.IlinkOutputFile: LRWAN_NS1.out
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../LoRaWAN/App/src/: bsp.c debug.c ee.c hw_gpio.c hw_rtc.c hw_usart.c lora_driver.c main.c tiny_sscanf.c tiny_vsnprintf.c
    ../Core/src/: stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
  group Drivers/BSP/I_NUCLEO_LRWAN1
    ../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1/: i_nucleo_lrwan1.c i_nucleo_lrwan1_humidity.c i_nucleo_lrwan1_pressure.c i_nucleo_lrwan1_temperature.c i_nucleo_lrwan1_wm_sg_sm_xx.c
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../Drivers/BSP/LRWAN_NS1/: lrwan_ns1.c lrwan_ns1_atcmd.c lrwan_ns1_humidity.c lrwan_ns1_pressure.c lrwan_ns1_temperature.c
  group Drivers/BSP/MDM32L07X01
    ../../../../../../Drivers/BSP/MDM32L07X01/: atcmd.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/loRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c
